# Keil uVision project CAN_Communication_Prj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN_Communication_Prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: .\BTN;.\CONTROL;.\LED;.\Libraries\CMSIS\Include;.\TIMER;.\UART;.\User;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\can-communication;.\CAN;.\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c main.h stm32f4xx_it.c stm32f4xx_it.h
  group CMSIS
    ./: startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group CAN
    ./CAN/: Can_Int.c Can_Int.h defines.h
  group UART
    ./UART/: uart.c uart.h
  group BTN
    ./BTN/: btn.h btn.c
  group LED
    ./LED/: led.c led.h
  group Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group TIMER
    ./TIMER/: timer.c timer.h
  group CONTROL
    ./CONTROL/: control.c control.h
software components: CMSIS:CORE 5.1.1
